!Keysight Technologies,N5245B,MY58422270,A.16.20.02
!Date: Tuesday, December 10, 2024 23:35:42
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (band-pass shape):
!   6401 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = 3.00 dB at 1.833 GHz (marker M1); lowest = -50.5 dB at 28.72 GHz (marker M2)
!   |S21| within 3 dB of the highest: 1.046 GHz to 11.33 GHz (10.28 GHz wide, 166 % of centre); 18.39 GHz to 20.52 GHz (2.127 GHz wide, 10.9 % of centre)
!   lowest |S11| = -45.9 dB at 16.68 GHz (marker M3), VSWR 1.01, Z = 49.6 - j0.263 ohm
!   |S11| at or under -10 dB: 155.2 MHz to 26.41 GHz (26.25 GHz wide, 198 % of centre); 27.13 GHz to 29.84 GHz (2.712 GHz wide, 9.52 % of centre)
!   |S22| runs from -30.2 to -5.3 dB; largest |S21 - S12| = 1.4
!   the Smith chart shows 3.599 GHz to 23.27 GHz only
!   S11 on the Smith chart (normalised r, x): 3.599 GHz: 1.02, +0.11; 21.75 GHz: 0.84, -0.16; 23.27 GHz: 0.85, +0.24
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -3.7  -18.3  -48.6  -23.8
! 192.8 MHz  -11.8  -12.4  -57.7  -30.0
! 534.8 MHz  -20.6  -33.4  -61.5  -19.5
! 1.046 GHz  -23.7  0.0  -57.0  -18.2
! 1.833 GHz  -25.0  3.0  -52.1  -19.5
! 3.599 GHz  -25.3  2.8  -54.4  -18.6
! 5.01 GHz  -25.3  2.7  -55.9  -18.2
! 7.648 GHz  -26.3  2.3  -53.3  -22.0
! 10.01 GHz  -24.1  1.2  -51.2  -15.9
! 12.16 GHz  -32.1  -1.0  -53.8  -15.7
! 15.01 GHz  -27.8  -1.6  -59.5  -14.3
! 16.68 GHz  -45.9  -0.7  -66.1  -11.3
! 18.32 GHz  -36.3  0.0  -51.2  -11.4
! 20 GHz  -26.7  0.4  -48.3  -11.8
! 21.75 GHz  -18.4  -5.2  -49.3  -14.8
! 23.27 GHz  -16.2  -16.5  -44.5  -14.7
! 25 GHz  -12.3  -21.8  -43.7  -16.5
! 27.46 GHz  -10.4  -30.8  -32.7  -8.9
! 28.72 GHz  -13.6  -50.5  -45.4  -5.4
! 29.36 GHz  -12.1  -36.3  -37.1  -8.8
! 29.71 GHz  -10.5  -35.1  -37.0  -16.1
! 30 GHz  -9.7  -36.2  -39.0  -12.5
