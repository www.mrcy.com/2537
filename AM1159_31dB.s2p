!Keysight Technologies,N5245B,MY58422270,A.16.20.02
!Date: Tuesday, December 10, 2024 23:45:07
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (one-way two-port):
!   6401 points, 10 MHz to 30 GHz, reference 50 ohm
!   highest |S21| = -12.29 dB at 1.861 GHz (marker M1); lowest = -50.4 dB at 28.37 GHz (marker M2)
!   lowest |S11| = -48.1 dB at 16.69 GHz (marker M3), VSWR 1.01, Z = 49.6 - j0.156 ohm
!   |S11| at or under -10 dB: 130.2 MHz to 26.56 GHz (26.42 GHz wide, 198 % of centre); 26.58991 GHz to 26.64651 GHz (56.59 MHz wide, 0.213 % of centre); 26.85 GHz to 29.94 GHz (3.092 GHz wide, 10.9 % of centre) (the widest 3 of 4)
!   |S22| runs from -30.1 to -5.1 dB; largest |S21 - S12| = 0.24
!   the Smith chart shows 3.773 GHz to 23.25 GHz only
!   S11 on the Smith chart (normalised r, x): 3.773 GHz: 1.04, +0.10; 21.83 GHz: 0.83, -0.16; 23.25 GHz: 0.83, +0.25
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -5.4  -22.5  -52.1  -23.6
! 230.2 MHz  -13.9  -27.9  -58.0  -28.4
! 530.1 MHz  -20.0  -47.9  -60.2  -19.6
! 1.05 GHz  -23.8  -15.1  -63.2  -18.6
! 1.861 GHz  -25.3  -12.3  -62.5  -18.4
! 3.773 GHz  -25.4  -12.5  -66.1  -20.5
! 5.01 GHz  -25.4  -12.5  -66.7  -18.3
! 10.01 GHz  -23.8  -14.1  -57.3  -16.6
! 12.17 GHz  -30.2  -16.9  -57.2  -16.9
! 15.01 GHz  -27.2  -19.0  -56.7  -13.7
! 15.85 GHz  -32.9  -18.6  -55.0  -13.3
! 16.69 GHz  -48.1  -18.0  -57.4  -12.6
! 17.45 GHz  -38.3  -17.3  -56.7  -11.8
! 20 GHz  -27.3  -14.7  -51.4  -11.0
! 21.83 GHz  -17.9  -19.6  -48.7  -14.9
! 23.25 GHz  -15.8  -28.8  -44.6  -15.1
! 25 GHz  -12.2  -33.5  -43.6  -16.5
! 27.5 GHz  -10.6  -33.2  -32.9  -8.5
! 28.37 GHz  -12.4  -50.4  -45.8  -5.3
! 29.33 GHz  -12.7  -36.1  -37.1  -8.3
! 29.7 GHz  -10.8  -36.1  -36.8  -16.6
! 30 GHz  -9.9  -37.6  -38.2  -12.4
